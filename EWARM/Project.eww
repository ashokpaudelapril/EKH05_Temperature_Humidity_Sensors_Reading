<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\EKH05_Temperature_Only.ewp</path>
  </project>
  <batchBuild />
</workspace>
